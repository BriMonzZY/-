# Keil uVision project 智能门锁.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 智能门锁 +hex
  c flags: Optimize=8 SizeSpeed=1
  group source files
    ../files/: main.c key.c smg.c IIC.c led.c app.c
  group include files
    ../files/: config.h key.h smg.h IIC.h main.h led.h app.h
